# Keil uVision project Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Test +hex
  c flags: Optimize=8
  c include: .\Listings
  group Source Group 1
    ./Listings/: DELAY.c Uart.c NEC_IR_decoding.c Digital_Tube.c
    ./: test.c
